# IAR project codebrick.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\User; ..\lib\CMSIS\Include; ..\lib\CMSIS\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\framework; ..\driver\inc; ..\..\..\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: codebrick.srec
  ILINK.IlinkOutputFile: codebrick.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group at_chat
    ../../../src/: at_chat.c
    ../user/: at_port.c
  group driver
    ../driver/src/: mcu_flash.c tty.c wifi_uart.c
  group framework
    ../framework/: blink.c cli.c key.c module.c queue.c ringbuffer.c
  group lib/CMSIS
    ../lib/CMSIS/STM32F4xx/Source/iar/: startup_stm32f4xx.s
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group lib/STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    ../user/: config.h led.c main.c platform.c public.c stm32f4xx_conf.h stm32f4xx_it.c
  group user/cmd
    ../user/cmd/: cmd_devinfo.c
  group user/task
    ../user/task/: cli_task.c task_key.c wifi_task.c
